# Keil uVision project STM32F4.uvproj, settings and files
target STM32F4 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries;..\Mylib;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c bsp.c
  group Mylib
    ../Mylib/: ad.c air_cylinder.c led.c key.c delay.c timer.c tim4.c pwm.c encoder.c can1.c can2.c uart4.c usart3.c usart2.c motor.c up_down.c chassis.c trailer.c
  group Libraries
    ../Libraries/: misc.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4xx_syscfg.c system_stm32f4xx.c startup_stm32f4xx.s stm32f4xx_flash.c
